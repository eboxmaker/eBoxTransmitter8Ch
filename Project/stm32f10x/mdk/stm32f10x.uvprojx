# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\component;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\component\FreeModbus\port;..\..\..\component\FreeModbus\modbus\ascii;..\..\..\component\FreeModbus\modbus\rtu;..\..\..\component\FreeModbus\modbus\tcp;..\..\..\component\FreeModbus\modbus\include;..\..\..\component\linearRegression;..\..\..\component\ddc;..\..\..\component\apps\Filters\normal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group eboxFun
    ../../../ebox/core/stdFun/: big_little.c crc.c ebox_mem.c ebox_printf.c fifo.c itoa.c math_misc.c util.c Dstring.cpp list.cpp new.cpp print.cpp random.cpp ringbuf.cpp sort.cpp WString.cpp
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp
    ../../../user/: ebox_init.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu.cpp ebox_it.cpp object.cpp nvic.cpp dma.cpp rcc.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_analog.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_gpio.cpp ebox_exti.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_timer.cpp ebox_uart.cpp ebox_wdg.cpp ebox_slave_spi.cpp
  group edriver
    ../../../component/edriver/: ads1118.cpp
  group modbus
    ../../../component/FreeModbus/modbus/ascii/: mbascii.c
    ../../../component/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../component/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../component/FreeModbus/modbus/tcp/: mbtcp.c
    ../../../component/FreeModbus/modbus/: mb.c
  group port
    ../../../component/FreeModbus/port/: portevent.c FreeModbus.cpp portserial.cpp porttimer.cpp
  group ddc
    ../../../component/ddc/: ddc.c ddc_list.c ddc_port.cpp ddc_user.cpp
  group app
    ../../../component/linearRegression/: LinearRegression.cpp
  group user
    ../../../user/: bsp.cpp main.cpp adjust.cpp
